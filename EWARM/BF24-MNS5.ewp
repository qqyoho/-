# IAR project BF24-MNS5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: FM33LG02x FMSH FM33LG02x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: FM33LG0XX; TIANFENG; BAT_8S; BATTARY_LFP; CAPCITY_100; NEGT_DEBUG
  ICCARM.CCIncludePath2: ..\app; ..\canopen\include; ..\driver; ..\FM33LG025\FM33LG0xx_FL_Driver\Inc; ..\FM33LG025\CMSIS\FM33xx; ..\communiation
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TFRY2-08S100MNS5_V4.00.02.hex
  ILINK.IlinkOutputFile: FM33LG0XX_Tester.out
  ILINK.IlinkIcfFile: D:\1_projects\NUOLI\EWARM0305(chuanlian)\EWARM\FM33LC02x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: BF24-RPX1-HSID_V0.03.txt
  group App
    ../app/: afe_app.c balance.c bluetooth.c can_app.c ch_addition.c chargerProtocol.c current_manage.c dataProcess.c fault_manage.c final_protect.c iap_app.c led_show.c low_power.c main.c mode_manage.c parameter.c peak_record.c protect_record.c run_record.c serial_no.c short.c soc.c soc_update.c storage_manage.c switch_status.c system_adjust.c system_control.c temp_manage.c vol_curr_addi_deal.c vol_manage.c
  group Canopen
    ../canopen/src/: can_open_timer.c lifegrd.c nmtMaster.c nmtSlave.c objacces.c objdict.c pdo.c sdo.c states.c sync.c
  group communiation
    ../communiation/: Appcommunication.c AppCommunication.h AppCurrManage.c AppCurrManage.h AppTempManage.c AppTempManage.h AppVolManage.c AppVolManage.h
  group Driver
    ../driver/: adc_sampling.c bsp_nor_flash.c can.c ch_detect.c ChHeart.c eeprom.c hardware.c idog.c JW3370.c key_status.c power.c rtc.c spi.c timer.c uart.c uart_dma.c
  group FM33LG025
    ../FM33LG025/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_opa.c fm33lg0xx_fl_pgl.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_u7816.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_wwdt.c
    ./: 编码规则.txt
  group FM33LG025/start
    ../FM33LG025/CMSIS/FM33xx/: startup_fm33lg0xx.s system_fm33lg0xx.c
