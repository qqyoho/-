<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BF24-MNS5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


